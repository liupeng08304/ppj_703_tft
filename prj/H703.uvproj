# Keil uVision project H703.uvproj, settings and files
target H703 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: H703 +hex
  c flags: Optim=1 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 NRF_LOG_USES_RTT
  c misc: --c99 --reduce_paths
  c include: ..\components\libraries\util;..\components\drivers_nrf\hal;..\components\device;..\components\boards;..\Include;..\band_kerwin;..\components\toolchain;..\components\softdevice\s132\headers;..\components\ble\common;.\config;..\components\ble\ble_advertising;..\components\softdevice\common\softdevice_handler;..\components\libraries\button;..\components\ble\nrf_ble_gatt;..\components\libraries\timer;..\components\ble\ble_services\ble_nus;..\components\libraries\log;..\components\libraries\uart;..\components\libraries\log\src;..\components\libraries\bsp;.\config;..\components\drivers_nrf\timer;..\components\libraries\strerror;..\components\libraries\fstorage;..\components\drivers_nrf\common;..\components\libraries\experimental_section_vars;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\delay;..\components\libraries\fifo;..\components\libraries\experimental_section_vars;..\external\segger_rtt;..\components\drivers_nrf\clock;..\components\drivers_nrf\uart;..\moudle\segger_rtt;..\prj;..\moudle\ble_fifo;..\moudle\sem;..\moudle\ui;..\moudle\s110_src;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_db_discovery;..\components\ble\peer_manager;..\components\libraries\fds;..\components\ble\ble_db_discovery;..\components\ble\peer_manager;..\components\libraries\scheduler;..\moudle\boot;..\moudle\inflashmanage;..\moudle\softrtc;..\moudle\wdt;..\moudle\sport;..\moudle\battery;..\moudle\sport;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\drivers_nrf\saadc;..\components\drivers_nrf\hal;..\components\drivers_nrf\spi_master;..\moudle\sport\hr;..\moudle\protocol;..\moudle\upfile;..\moudle\hrs3000;..\components\toolchain\cmsis\include
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\..\..\config\ble_app_uart_pca10040_s132;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x1e000
  memory RVCT9: RAM 0x20002180 size 0x6000
  link misc: --diag_suppress 6330
  group Application
    ./: main.c sdk_config.h bsp.c
    ../moudle/sem/: utility.c sem.c button52.c
    ../moudle/inflashmanage/: data_use_api.c in_flash_manage.c queueu51822.c
    ../moudle/boot/: boot.c
    ../moudle/softrtc/: SoftwareRTC.c
    ../moudle/wdt/: wdt.c
  group Device
    ../components/toolchain/arm/: arm_startup_nrf52.s
    ../components/toolchain/: system_nrf52.c
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../components/ble/peer_manager/: gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c gatt_cache_manager.c
    ../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../components/ble/ble_services/ble_nus/: ble_nus.c
    ../components/ble/ble_services/ble_ancs_c/: nrf_ble_ancs_c.c ancs_app_attr_get.c ancs_attr_parser.c ancs_tx_buffer.c
  group nRF_Drivers
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../components/libraries/csense/: nrf_csense.c
    ../components/libraries/csense_drv/: nrf_drv_csense.c
    ../moudle/battery/: Battery_ADC.c
  group nRF_Libraries
    ../components/libraries/button/: app_button.c
    ../components/libraries/fifo/: app_fifo.c
    ../components/libraries/scheduler/: app_scheduler.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../components/libraries/util/: app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../components/libraries/fstorage/: fstorage.c
    ../components/libraries/hardfault/: hardfault_implementation.c
    ../components/libraries/strerror/: nrf_strerror.c
    ../components/libraries/crc16/: crc16.c
    ../components/libraries/fds/: fds.c
    ../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../components/drivers_nrf/hal/: nrf_saadc.c
    ../components/drivers_nrf/spi_master/: nrf_drv_spi.c
  group nRF_Segger_RTT
    ../moudle/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group BLE
    ../moudle/s110_src/: s132config.c rfid52.c upfile.c
    ../moudle/protocol/: protocol.c
    ../moudle/ble_fifo/: ble_fifo.c
  group sport
    ../moudle/sport/: pedometer_klx.c sleep.c spi52.c lis3dh_driver.c alarm.c
    ../moudle/upfile/: ex_flash.c
  group ui
    ../moudle/ui/: font_band.c lcd.c ui_app.c ui_time.c ui_support.c
  group hr
    ../moudle/sport/hr/: hr_app.c
    ../moudle/hrs3000/: hrs3300.c m4_keil_20170828_v19_15d..lib iic_gpio.c
